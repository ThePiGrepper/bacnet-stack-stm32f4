# Keil uVision project bacnet-stack-stm32f10x.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bacnet-stack-stm32f10x
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL,HSE_VALUE=25000000,NDEBUG,BACDL_MSTP=1,BACAPP_ALL,MAX_APDU=480,BIG_ENDIAN=0,MAX_TSM_TRANSACTIONS=0,MAX_CHARACTER_STRING_BYTES=64,MAX_OCTET_STRING_BYTES=64,PRINT_ENABLED=0
  c include: ..\stm32f10x;.\drivers\inc;.\CMSIS;..\..\include;..\..\demo\object;..\..\demo\handler
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Bacnet_Platform
    ./: main.c automac.c bacnet.c bo.c device.c dlmstp.c led.c rs485.c stm32f10x_it.c system_stm32f10x.c timer.c timer_sys.c
  group Bacnet_Demo
    ../../demo/handler/: h_dcc.c h_npdu.c h_rd.c h_rp.c h_rpm.c h_whohas.c h_whois.c h_wp.c noserv.c s_iam.c s_ihave.c txbuf.c
  group Bacnet_Core
    ../../src/: abort.c apdu.c bacaddr.c bacapp.c bacdcode.c bacerror.c bacint.c bacreal.c bacstr.c crc.c dcc.c fifo.c iam.c ihave.c lighting.c memcopy.c npdu.c proplist.c rd.c reject.c ringbuf.c rp.c rpm.c whohas.c whois.c wp.c
  group STM32
    ./drivers/src/: stm32f10x_gpio.c stm32f10x_misc.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c syscalls.c
  group Startup
    ./CMSIS/arm/: startup_stm32f10x_xl.s
